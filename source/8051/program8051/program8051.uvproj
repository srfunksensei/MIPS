# Keil uVision project program8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: program8051
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 program8051.c program8051.h
